FILESEXTRAPATHS_prepend := "${THISDIR}/ompl:"

SRC_URI += "file://0001-address-gcc6-compile-error.patch"

